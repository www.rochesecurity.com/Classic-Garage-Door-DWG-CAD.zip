Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-03-03T08:17:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.30.41
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Mar 03 08:17:23 2022* Host: BIMServices* Database: C:\Users\PIOTRB~1\AppData\Local\Temp\{60C3D617-5362-4023-A0DB-4B72D2F613CB}\ifc* Database version: 5507* Database creation date: Thu Mar 03 08:17:22 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Mar 03 08:17:23 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Mar 03 08:17:23 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcDoor: 2500x2000mm, NBS_RocheSystemsLtd_RllrShtrSets_ClassicRollerGarageDoor:2500x2000mm:371783
In: Level 0
Type - OperationType: ROLLINGUP; ConstructionType: ALUMINIUM; ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_30_59_84_73 (Uniclass2015); Material: NBS_RocheSystems_Curtain77mm_White, NBS_RocheSystems_White
Type - NBS_RocheSystemsLtd_RllrShtrSets_ClassicRollerGarageDoor:2500x2000mm:371783 - PanelOperation: ROLLINGUP
Type - BOS_General - Author: NBS; BIMObjectName: NBS_RochéSystemsLtd_RollerShutters_ClassicRollerGarageDoor; ManufacturerName: Roché Systems Ltd; ManufacturerURL: www.rochesystems.com; NBSCertification: www.nationalbimlibrary.com/cert/0dvxem0l; ProductInformation: n/a; Uniclass2015Title: Roller shutters; Uniclass2015Code: Pr_30_59_84_73; Uniclass2015Version: Products v1.22; Version: 1
Type - NBS_Data - Accessories: None, External override facility, Vision slats; Arrangement: Vertical, external face, Vertical, internal face, Vertical, reveal fix; ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; EmbodiedCarbon: n/a; EnclosureType: Box, Circular; Execution: n/a; Format: n/a; FrameAndGuidesColourFilmThicknessMinimum: n/a; FrameAndGuidesColourFrameAccessories: n/a; FrameAndGuidesColourInstallationFasteners: n/a; FrameAndGuidesFinish: n/a; FrameAndGuidesMaterial: n/a; GuideChannels: Brown, White, BS, RAL; GuideChannelsDepth: 70 mm, 90 mm, 150 mm; Hardware: n/a; OpeningSizes: 5500 x 2750 mm; Operation: ROLLINGUP; OperationControl: Somfy tubular motor with safety sensor, courtesy light, alarm and two key fobs, NRG tubular motor with safety sensor, courtesy light, alarm and two key fobs.; OperationMode: Electric, NRG Econom tubular motor, Electric, Somfy tubular motor, Manual, spring and lock, Manual, rod and crank,Manual, cord belt; PerformanceAcousticPerformance: n/a; PerformanceAirPermeability: n/a; PerformanceOperatingForces: n/a; PerformanceResistanceToWindLoad: n/a; PerformanceThermalResistance: n/a; PerformanceWatertightness: n/a; Recyclability: n/a; RecycledContent: n/a; ShutterCurtainFinishAndColour: Anthracite, RAL 7016, Beige, BS 08B17, Black, RAL 9005, Brown, RAL 8019, Moss green, RAL 6005, Light grey, RAL 7038, Moss green, RAL 6005, Painted oak, Painted rosewood, Painted teak, Red, RAL 3004, Sage green, RAL 6021, Silver, RAL 9006, Steel blue, RAL 5011, White, RAL 9016, Laminate golden oak, Laminate Irish oak, Laminate mahogany, Laminate rosewood; ShutterCurtainLathMaterial: 20 mm thick aluminium with foam insulating core, 78 mm in height.; ShutterCurtainProfile: n/a; Standard: n/a; Weight: 5.5 kg/m²
Type - IFC - IfcExportAs: IfcDoor; IfcExportType: DOOR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_84_73:Roller shutters; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Double skinned insulated aluminium roller garage door with 78 mm high slats; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: info@rochesystems.com; Material: n/a; ModelNumber: n/a; ModelReference: Classic Roller Garage Door; Name: RollerShutters_ClassicRollerGarageDoor_RochéSystemsLtd; NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OverallHeight: 2300 mm; OverallWidth: 2680 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
